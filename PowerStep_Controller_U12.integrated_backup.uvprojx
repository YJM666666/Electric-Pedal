# Keil uVision project PowerStep_Controller_U12.integrated_backup.uvprojx, settings and files
target U12_Brushed_Master (6210000::V6.21::ARMCLANG)
  device: GD32C103CB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU0 CLOCK(120000000) ELITTLE
  output: Electric_Pedal_U12 +hex
  BeforeMake: tools\build_u12_bootloader_target.cmd
  AfterMake: tools\postbuild_u12_factory.cmd
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32C10X,BSP_TARGET_GD32C103,APP_ROLE_U12_MAIN
  c include: .;.\app;.\boot;.\bsp;.\control;.\driver;.\service;.\config;.\config\board;.\config\protocol;.\vendor\GD32C10x_Firmware_Library_V1.7.0\Firmware\CMSIS;.\local_include\c10x;.\vendor\GD32C10x_Firmware_Library_V1.7.0\Firmware\CMSIS\GD\GD32C10x\Include;.\vendor\GD32C10x_Firmware_Library_V1.7.0\Firmware\GD32C10x_standard_peripheral\Include
  asm include: .\local_include\c10x;.\vendor\GD32C10x_Firmware_Library_V1.7.0\Firmware\CMSIS;.\vendor\GD32C10x_Firmware_Library_V1.7.0\Firmware\CMSIS\GD\GD32C10x\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Electric_Pedal_U12_app.sct
  group App
    ./app/: main.c
  group BSP
    ./bsp/: bsp_adc.c bsp_can.c bsp_gpio.c bsp_motor_hall.c bsp_i2c.c bsp_platform.c bsp_spi.c bsp_timer.c bsp_uart.c bsp_voice.c bsp_wdg.c bsp_iflash.c
  group Boot
    ./boot/: boot_info.c boot_image.c boot_crc32.c bootloader_blob.c
  group Control
    ./control/: policy.c scheduler.c motor_feedback.c step_sm.c sys_sm.c
  group Driver
    ./driver/: drv_light.c drv_motor.c drv_motor_backend.c drv_motor_backend_relay.c drv_voice.c drv_nvm.c
  group Service
    ./service/: ble_if.c can_if.c current_guard.c event_collector.c event_flags.c motor_pulse_latch.c event_report_service.c motor_profile.c voice_announce_service.c step_executor.c ota_service.c event.c fault.c param.c sw_timer.c u17_link.c u17_proto.c voice_catalog.c app_cmd_dispatch.c app_proto_v2.c
  group CMSIS
    ./: startup_gd32c10x_ac6.c
    ./vendor/GD32C10x_Firmware_Library_V1.7.0/Firmware/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group FWLib
    ./vendor/GD32C10x_Firmware_Library_V1.7.0/Firmware/GD32C10x_standard_peripheral/Source/: gd32c10x_adc.c gd32c10x_bkp.c gd32c10x_can.c gd32c10x_crc.c gd32c10x_ctc.c gd32c10x_dac.c gd32c10x_dbg.c gd32c10x_dma.c gd32c10x_exmc.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_fwdgt.c gd32c10x_gpio.c gd32c10x_i2c.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_rtc.c gd32c10x_spi.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_wwdgt.c
