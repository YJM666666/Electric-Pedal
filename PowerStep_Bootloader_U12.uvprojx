# Keil uVision project PowerStep_Bootloader_U12.uvprojx, settings and files
target U12_Bootloader (6210000::V6.21::ARMCLANG)
  device: GD32C103CB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU0 CLOCK(120000000) ELITTLE
  output: Electric_Pedal_U12_Bootloader +hex
  AfterMake: fromelf --bin -o ".\Objects\Boot\Electric_Pedal_U12_Bootloader.bin" ".\Objects\Boot\Electric_Pedal_U12_Bootloader.axf"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32C10X,BSP_TARGET_GD32C103
  c include: .;.\boot;.\bsp;.\config;.\config\board;.\config\protocol;.\driver;.\service;.\local_include\c10x;.\vendor\GD32C10x_Firmware_Library_V1.7.0\Firmware\CMSIS;.\vendor\GD32C10x_Firmware_Library_V1.7.0\Firmware\CMSIS\GD\GD32C10x\Include;.\vendor\GD32C10x_Firmware_Library_V1.7.0\Firmware\GD32C10x_standard_peripheral\Include
  asm include: .\local_include\c10x;.\vendor\GD32C10x_Firmware_Library_V1.7.0\Firmware\CMSIS;.\vendor\GD32C10x_Firmware_Library_V1.7.0\Firmware\CMSIS\GD\GD32C10x\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Electric_Pedal_U12_boot.sct
  group Boot
    ./boot/: boot_main_u12.c boot_info.c boot_image.c boot_crc32.c boot_jump.c boot_extflash.c
  group BSP
    ./bsp/: bsp_iflash.c bsp_i2c.c bsp_spi.c bsp_platform.c bsp_wdg.c bsp_gpio.c
  group CMSIS
    ./: startup_gd32c10x_ac6.c
    ./vendor/GD32C10x_Firmware_Library_V1.7.0/Firmware/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group FWLib
    ./vendor/GD32C10x_Firmware_Library_V1.7.0/Firmware/GD32C10x_standard_peripheral/Source/: gd32c10x_fmc.c gd32c10x_gpio.c gd32c10x_i2c.c gd32c10x_rcu.c gd32c10x_spi.c gd32c10x_fwdgt.c gd32c10x_misc.c
