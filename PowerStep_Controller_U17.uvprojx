# Keil uVision project PowerStep_Controller_U17.uvprojx, settings and files
target U17_Light_Voice (6210000::V6.21::ARMCLANG)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(48000000) ELITTLE
  output: Electric_Pedal_U17 +hex
  AfterMake: fromelf --bin -o ".\Objects\U17\Electric_Pedal_U17.bin" ".\Objects\U17\Electric_Pedal_U17.axf"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER GD32F130_150 BSP_TARGET_GD32F130 APP_ROLE_U17_SLAVE
  c include: .\;.\app;.\bsp;.\control;.\driver;.\service;.\u17_slave\app;.\u17_slave\control;.\u17_slave\service;.\vendor\GD32F1x0_Firmware_Library_V3.8.0\Firmware\CMSIS;.\vendor\GD32F1x0_Firmware_Library_V3.8.0\Firmware\CMSIS\GD\GD32F1x0\Include;.\vendor\GD32F1x0_Firmware_Library_V3.8.0\Firmware\GD32F1x0_standard_peripheral\Include
  asm include: .\vendor\GD32F1x0_Firmware_Library_V3.8.0\Firmware\CMSIS\GD\GD32F1x0\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group App
    ./u17_slave/app/: u17_main.c
  group BSP
    ./bsp/: bsp_adc.c bsp_can.c bsp_gpio.c bsp_i2c.c bsp_platform.c bsp_spi.c bsp_timer.c bsp_uart.c bsp_voice.c bsp_wdg.c
  group Service
    ./service/: event_flags.c sw_timer.c u17_proto.c voice_catalog.c
  group U17_Service
    ./u17_slave/service/: u12_u17_slave_link.c
  group U17_Control
    ./u17_slave/control/: u17_exec.c
  group CMSIS
    ./: startup_gd32f1x0_ac6.c
    ./vendor/GD32F1x0_Firmware_Library_V3.8.0/Firmware/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group FWLib
    ./vendor/GD32F1x0_Firmware_Library_V3.8.0/Firmware/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_misc.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
